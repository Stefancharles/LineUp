# Keil uVision project Template.uvprojx, settings and files
target newland-queuing-machine (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: newland-queuing-machine +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG_BOOT=0,DEBUG_SHELL=0
  c include: ..\sys\systick;..\sys\sys;..\sys\;..\bsp;..\lib;..\lib\STM32F10x_FWLib\inc;..\app\usmart;..\app\usmart\usart;..\app\WiFiToCloud;..\app\pwd;..\app\potocol;..\app;..\drivers\;..\drivers\TIMER;..\drivers\KEY;..\drivers\LCD12864;..\drivers\xfs5152ce;..\drivers\si4332;..\drivers\lf125k;..\drivers\Buzzer;..\drivers\SegLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c hal_core.c hal_core.h
    ../app/pwd/: app_pwd.c app_pwd.h
  group app/shell
    ../app/usmart/: usmart.c usmart_config.c usmart_str.c
    ../app/usmart/usart/: usart.c
  group app/cloud
    ../app/WiFiToCloud/: HAL_WiFiToCloud.c WiFiToCloud.c app_cloud.c app_cloud.h CloudReference.h
  group app/potocol
    ../app/potocol/: potocol.c potocol.h
  group bsp
    ../bsp/: bsp_flash.c usart3.c timer.c bsp_spi.c bsp_spi.h bsp_spi1.c bsp_spi1.h bsp_uart4.c bsp_uart4.h bsp_rtc.c bsp_timer3.c
  group driver
    ../drivers/LCD12864/: LCD12864.c
    ../drivers/lf125k/: lf125k.c
    ../drivers/xfs5152ce/: xfs5152ce.c
    ../drivers/Buzzer/: buzzer.c
    ../drivers/si4332/: rf_si4332a.c rf_si4332a.h rf_si4332b.c rf_si4332b.h
    ../drivers/KEY/: key_button.c
    ../drivers/SegLED/: 74hc595.c ledNixietube.c
  group lib/stm32lib
    ../lib/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../lib/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group sys
    ../sys/: kfifo.c delay.c
    ../sys/sys/: sys.c
    ../sys/systick/: systick.c
